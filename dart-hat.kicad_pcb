# Repository kemfic/dart-hat

## KiCad design dart-hat.kicad_pcb

Parts:
C1: 10uF; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder; Manufacturer_Part_Number GRM188R61E106KA73J
C2: 0.1uF; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder; Manufacturer_Part_Number C0603C104K4RACTU
CP1: 470uF; CP_Elec_10x10.5; Manufacturer_Part_Number APXH6R3ARA471MJ80G
D1: D_Zener; D_SOT-23_ANK; Manufacturer_Part_Number BZX84C15VLYFHT116
D2: LED_Small; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder; Manufacturer_Part_Number HSME-C170
D3: LED_Small; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder; Manufacturer_Part_Number HSMA-C170
D4: D_Schottky; D_SOD-128; Manufacturer_Part_Number RB088LAM-40TR
F1: 3A; Fuse_Bourns_MF-SM_7.98x5.44mm; Manufacturer_Part_Number MF-LSMF300X-2
J1: XT60 Female; AMASS_XT60PW-M; Manufacturer_Part_Number XT60
J2: Raspberry_Pi_2_3; PinHeader_2x20_P2.54mm_Vertical
JP1: Jumper_NO_Small; PinHeader_1x02_P2.54mm_Vertical
Q1, Q2: SI7611DN-T1-GE3; VISHAY_SIS468DN-T1-GE3; PARTREV B
Q3: DMMT5401; SOT95P285X140-6N; PARTREV 8
R1, R2, R3: 10k; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder; Manufacturer_Part_Number PHP00603E1002BST1
R4: 120; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder; Manufacturer_Part_Number ERA-6VEB1200V
R5: 62; R_1206_3216Metric_Pad1.42x1.75mm_HandSolder; Manufacturer_Part_Number ERA-8AED620V
R6, R7: 3.9k; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder; Manufacturer_Part_Number ERA-3VEB3901V
R8, R9, R11, R12, R13: 4.7k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder; Manufacturer_Part_Number ERA-6VEB4701V
R10: 1k; R_0402_1005Metric; Manufacturer_Part_Number ERA-2VRW1001X
TP1, TP2, TP4, TP5: TestPoint; TestPoint_Pad_D1.0mm
U1: CAT24C32YI-GT3; SOP65P640X120-8N; Manufacturer_Part_Number CAT24C32YI-GT3

Connections:
+3V3_PI: C1.1, C2.1, J2.1 (3V3), J2.17 (3V3), R6.1, R7.1, R8.1, R9.1, R10.1, R11.2, R12.2, R13.2, U1.8 (VCC); also elsewhere on the board
+5V: F1.1, J2.2 (5V), J2.4 (5V), Q2.1, Q2.2, Q2.3, Q3.5, TP4.1; also elsewhere on the board
+BATT: CP1.1, D1.1 (K), D4.1 (K), Q1.1, Q1.2, Q1.3, TP1.1; also elsewhere on the board
/5V Power Supply/VOUT: Q2.5, Q2.6, Q2.7, Q2.8, Q2.9, Q3.6; also elsewhere on the board
/BMI_INT: J2.22 (GPIO25); also elsewhere on the board
/CAN_INT: J2.16 (GPIO23); also elsewhere on the board
/CS_ACCEL: J2.26 (~CE1~/GPIO7), R12.1; also elsewhere on the board
/CS_CAN: J2.36 (GPIO16), R11.1; also elsewhere on the board
/CS_GYRO: J2.24 (~CE0~/GPIO8), R13.1; also elsewhere on the board
/ID_SC: J2.28 (ID_SC/GPIO1), R7.2, U1.6 (SCL); also elsewhere on the board
/ID_SD: J2.27 (ID_SD/GPIO0), R6.2, U1.5 (SDA); also elsewhere on the board
/LED0: D2.2 (A), J2.32 (PWM0/GPIO12); also elsewhere on the board
/LED1: D3.2 (A), J2.33 (PWM1/GPIO13); also elsewhere on the board
/MISO_CAN: J2.35 (GPIO19/MISO1); also elsewhere on the board
/MISO_IMU: J2.21 (MISO0/GPIO9); also elsewhere on the board
/MOSI_CAN: J2.38 (GPIO20/MOSI1); also elsewhere on the board
/MOSI_IMU: J2.19 (MOSI0/GPIO10); also elsewhere on the board
/SCL: J2.5 (SCL/GPIO3), R9.2; also elsewhere on the board
/SCLK_CAN: J2.40 (GPIO21/SCLK1); also elsewhere on the board
/SCLK_IMU: J2.23 (SCLK0/GPIO11); also elsewhere on the board
/SDA: J2.3 (SDA/GPIO2), R8.2; also elsewhere on the board
/Servo Driver/5V_IN: F1.2, TP5.1; also elsewhere on the board
/WP_EN: JP1.1, R10.2, U1.7 (WP)
GND: C1.2, C2.2, CP1.2, D4.2 (A), J1.2, J2.6 (GND), J2.9 (GND), J2.14 (GND), J2.20 (GND), J2.25 (GND), J2.30 (GND), J2.34 (GND), J2.39 (GND), JP1.2, R1.2, R2.2, R3.2, R4.1, R5.1, U1.1 (A0), U1.2 (A1), U1.3 (A2), U1.~ (GND); also elsewhere on the board
unnamed: D1.2 (A), Q1.4, R1.1, TP2.1
unnamed: D2.1 (K), R4.2
unnamed: D3.1 (K), R5.2
unnamed: J1.1, Q1.5, Q1.6, Q1.7, Q1.8, Q1.9
unnamed 59: J2.7 (GCLK0/GPIO4); also elsewhere on the board
unnamed 60: J2.8 (GPIO14/TXD); also elsewhere on the board
unnamed 61: J2.10 (GPIO15/RXD); also elsewhere on the board
unnamed 62: J2.11 (GPIO17); also elsewhere on the board
unnamed 63: J2.12 (GPIO18/PWM0); also elsewhere on the board
unnamed 64: J2.13 (GPIO27); also elsewhere on the board
unnamed 65: J2.15 (GPIO22); also elsewhere on the board
unnamed 66: J2.18 (GPIO24); also elsewhere on the board
unnamed 67: J2.29 (GCLK1/GPIO5); also elsewhere on the board
unnamed 68: J2.31 (GCLK2/GPIO6); also elsewhere on the board
unnamed 69: J2.37 (GPIO26); also elsewhere on the board
unnamed: Q2.4, Q3.4, R3.1
unnamed: Q3.1, Q3.2, Q3.3, R2.1

Notes on the sheet:
Lipo Power
i2c pullup
reverse polarity protection
bypass
shunt
backpowering via lipo compliant with hat spec github.com/raspberrypi/hats
spi pullup
eeprom
GPIO LEDs

Parts:
C3, C4: 36pF; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder; Manufacturer_Part_Number C0603C220F5GACAUTO
C5, C7, C8: 0.1uF; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder; Manufacturer_Part_Number C0603C104K4RACTU
C6: 10uF; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder; Manufacturer_Part_Number GRM188R61E106KA73J
C9: 1uF; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder; Manufacturer_Part_Number UMK107AB7105KA-T
J3: CAN_CON; JST_PH_S4B-PH-SM4-TB_1x04-1MP_P2.00mm_Horizontal
JP2, JP3: Jumper; PinHeader_1x02_P2.54mm_Vertical
R14: 120; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder; Manufacturer_Part_Number ERA-6VEB1200V
R15: 10k; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder; Manufacturer_Part_Number CPF0603D10KE
TP6, TP7: TestPoint; TestPoint_Pad_D1.0mm
U2: MCP2515-xST; SOP65P640X110-20N
U3: MCP2562-H-P; SOIC127P600X175-8N; Manufacturer_Part_Number MCP2562-H-P
Y1: 16MHz; Crystal_HC49-U_Vertical; Manufacturer_Part_Number FC4STCBMF16.0-BAG200

Connections:
+3V3: C5.1, C6.1, C7.1, R15.1, U2.20, U3.5 (Vio); also elsewhere on the board
+5V: C8.1, C9.1, U3.3 (VDD); also elsewhere on the board
/CAN_INT: JP3.2; also elsewhere on the board
/CS_CAN: U2.18; also elsewhere on the board
/MISO_CAN: U2.17; also elsewhere on the board
/MOSI_CAN: U2.16; also elsewhere on the board
/SCLK_CAN: U2.14; also elsewhere on the board
GND: C3.2, C4.1, C5.2, C6.2, C7.2, C8.2, C9.2, J3.1, J3.4, U2.10, U3.2 (VSS), U3.8 (SHDN), U3.9 (PAD); also elsewhere on the board
unnamed: C3.1, U2.8, Y1.1
unnamed: C4.2, U2.9, Y1.2
unnamed: JP2.1, R14.1
unnamed: JP3.1, U2.13
unnamed: R15.2, U2.19
unnamed: U2.1, U3.1 (TXD)
unnamed: U2.2, U3.4 (RXD)

Notes on the sheet:
CAN Connector
CAN Termination

Parts:
C10, C11, C12: 10uF; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder; Manufacturer_Part_Number GRM188R61E106KA73J
IC1: PCA9615DPJ; PCA9615_SOP50P490; Manufacturer_Part_Number PCA9615DPJ; Mouser_Part_Number 771-PCA9615DPJ
J4: SM07B-SRSS-TBLFSN; JST-SM07B-SRSS-TBLFSN-0; Manufacturer_Part_Number SM07B-SRSS-TBLFSN; digikey description 7 Positions Header, Shrouded Connector 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
JP4, JP6: Jumper; PinHeader_1x02_P2.54mm_Vertical
JP5: Jumper_NO_Small; PinHeader_1x02_P2.54mm_Vertical
R16, R17: 120; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder; Manufacturer_Part_Number ERA-6VEB1200V
R25, R26, R34, R35: 390; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder

Connections:
+3V3: C11.1, C12.1, IC1.1 (VDD(A)), IC1.10 (VDD(B)), J4.5, R25.1, R26.1; also elsewhere on the board
/SCL: IC1.4 (SCL); also elsewhere on the board
/SDA: IC1.2 (SDA); also elsewhere on the board
/differential i2c iface/SCL+: IC1.7 (DSCLP), J4.2, JP6.1, R26.2
/differential i2c iface/SCL-: IC1.6 (DSCLM), J4.1, R17.1, R35.2
/differential i2c iface/SDA+: IC1.8 (DSDAP), J4.3, JP4.1, R25.2
/differential i2c iface/SDA-: IC1.9 (DSDAM), J4.4, R16.1, R34.2
/differential i2c iface/SHLD: J4.7, JP5.2
GND: C10.2, C11.2, C12.2, IC1.5 (GND), J4.6, R34.1, R35.1; also elsewhere on the board
unnamed: C10.1, JP5.1
unnamed: JP4.2, R16.2
unnamed: JP6.2, R17.2

Notes on the sheet:
NOTE: might want to add flyback diodes and current protection here.
di2c termination
di2c biasing

Parts:
C13: 0.1uF; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder; Manufacturer_Part_Number C0603C104K4RACTU
C14: 10uF; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder; Manufacturer_Part_Number GRM188R61E106KA73J
JP7: Jumper_NO_Small; PinHeader_1x02_P2.54mm_Vertical
U4: BMI088; PQFN50P450X300X100-16N; Manufacturer_Part_Number BMI088

Connections:
+3V3_PI: C13.1, C14.1, U4.3 (VDD), U4.11 (VDDIO); also elsewhere on the board
/BMI_INT: JP7.2, U4.12 (INT3); also elsewhere on the board
/CS_ACCEL: U4.14 (CSB1); also elsewhere on the board
/CS_GYRO: U4.5 (CSB2); also elsewhere on the board
/IMU/INT1_A: JP7.1, U4.16 (INT1)
/IMU/INT2_A: U4.1 (INT2)
/IMU/INT4_G: U4.13 (INT4)
/MISO_IMU: U4.10 (SDO2), U4.15 (SDO1); also elsewhere on the board
/MOSI_IMU: U4.9 (SDA/SDI); also elsewhere on the board
/SCLK_IMU: U4.8 (SCL/SCK); also elsewhere on the board
GND: C13.2, C14.2, U4.4 (GNDA), U4.6 (GNDIO), U4.7 (PS); also elsewhere on the board

Notes on the sheet:
NOTES: bmi088 driver has DRDY wired to gpio26 (pin 6 on wiringpi) - i2c should be easier but i'm going for SPI since the old implementation works - shuttle has interrupt pin jumper - might want to not only expose the jumper for this, but also tie in 2 separate GPIO pins with the 2.54mm headers on e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

Parts:
C15: 0.1uF; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder; Manufacturer_Part_Number C0603C104K4RACTU
C16: 10uF; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder; Manufacturer_Part_Number GRM188R61E106KA73J
CP2: 470uF; CP_Elec_10x10.5; Manufacturer_Part_Number APXH6R3ARA471MJ80G
D5: PWR_LED_SERVO; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder; Manufacturer_Part_Number HSMA-C170
D6: D_Schottky_KKA; D_SOD-128; Manufacturer_Part_Number RB088LAM-40TR
M1, M2, M3, M4: Motor_Servo; PinHeader_1x03_P2.54mm_Vertical
R18: 150; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder; Manufacturer_Part_Number RP73D2A150RBTG
R19: 10k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder; Manufacturer_Part_Number PTN0805Y1002BST1
R20, R21, R22, R23: 220; R_1206_3216Metric_Pad1.42x1.75mm_HandSolder; Manufacturer_Part_Number HRG3216P-2200-B-T1
U5: PCA9685PW; TSSOP-28_4.4x9.7mm_P0.65mm; Manufacturer_Part_Number PCA9685PW

Connections:
+3V3: C15.1, C16.1, U5.28 (VDD); also elsewhere on the board
/SCL: U5.26 (SCL); also elsewhere on the board
/SDA: U5.27 (SDA); also elsewhere on the board
/Servo Driver/5V_IN: CP2.1, D5.2 (A), D6.2 (K), M1.2 (+), M2.2 (+), M3.2 (+), M4.2 (+); also elsewhere on the board
/Servo Driver/PWM0: R20.2, U5.6 (LED0)
/Servo Driver/PWM1: R21.2, U5.7 (LED1)
/Servo Driver/PWM2: R22.2, U5.8 (LED2)
/Servo Driver/PWM3: R23.2, U5.9 (LED3)
GND: C15.2, C16.2, CP2.2, D6.3 (A), M1.3 (-), M2.3 (-), M3.3 (-), M4.3 (-), R18.1, R19.1, U5.14 (VSS), U5.25 (EXTCLK); also elsewhere on the board
unnamed: D5.1 (K), R18.2
unnamed: M1.1 (PWM), R20.1
unnamed: M2.1 (PWM), R21.1
unnamed: M3.1 (PWM), R22.1
unnamed: M4.1 (PWM), R23.1
unnamed: R19.2, U5.23 (~OE)

Notes on the sheet:
TODO: - reverse voltage protection (backcurrent) - decoupling - fuses - power setup
NOTE: should the bypass cap and flyback diode be in series or parallel? NOTE: check BEC sheet and remove redundant components

Parts:
C17, C37: 10uF; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder; Manufacturer_Part_Number GRM188R61E106KA73J
U6: IFX27001TFV; TO-252-2; Manufacturer_Part_Number IFX27001TFV

Connections:
+3V3: C37.1, U6.2 (Vout); also elsewhere on the board
+5V: C17.1, U6.3 (Vin); also elsewhere on the board
GND: C17.2, C37.2, U6.1 (GND); also elsewhere on the board

Notes on the sheet:
C > 10uF and ESR < 10 Ohms Connect to heatsink area.

Parts:
C18, C19, C20, C21, C23: 2.2uF; C_1210_3225Metric_Pad1.42x2.65mm_HandSolder; Manufacturer_Part_Number GRM32ER72A225KA35L
C22: 270pF; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder; Manufacturer_Part_Number GRM1885C2A271JA01D
C24, C27: 0.022uF; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder; Manufacturer_Part_Number GRM188R72A223KAC4D
C26, C31: 100pF; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder; Manufacturer_Part_Number 06031A101FAT2A
C28, C36: 0.1uF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder; Manufacturer_Part_Number C2012X7R2A104K125AA
C29: 1uF; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder; Manufacturer_Part_Number GCM188R71C105KA64J
C30: 0.1uF; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder; Manufacturer_Part_Number GRM188R72A104KA35D
C32: 0.015uF; C_0402_1005Metric; Manufacturer_Part_Number GRM155R71H153KA12D
C33: 1000pF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder; Manufacturer_Part_Number GRM2195C2A102JA01D
C34, C35: 47uF; C_1210_3225Metric_Pad1.42x2.65mm_HandSolder; Manufacturer_Part_Number GRM32ER61C476KE15L
CP4: 470uF; CP_Elec_10x10.5; Manufacturer_Part_Number APXH6R3ARA471MJ80G
D7: NU; D_SOD-128
D8: Diode_Schottky_Common_Cathode; NEXPERIA_PMEG045V150EPDZ; Manufacturer_Part_Number MBRB1545CTT4G
L1: 6.8uH; L_6.3x6.3_H3; Manufacturer_Part_Number HC9-6R8-R
Q4: Q_NMOS_SGD; CSD18511Q5AT
R24: NU; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder; Manufacturer_Part_Number N/A
R27: 24.9k; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder; Manufacturer_Part_Number RT0603FRE0724K9L
R28: 0.01; RESC2037X70N; Manufacturer_Part_Number RL3720WT-R010-F
R29: 18k; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder; Manufacturer_Part_Number RN73H1JTTD1802F100
R30: 5.11; R_2512_6332Metric_Pad1.52x3.35mm_HandSolder; Manufacturer_Part_Number ERJ-1TRQF5R1U
R31: 10; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder; Manufacturer_Part_Number SFR10EZPF10R0
R32: 5.11k; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder; Manufacturer_Part_Number ERJ-3EKF5111V
R33: 1.62k; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder; Manufacturer_Part_Number CR0603-FX-1621ELF
TP14: TestPoint; TestPoint_Pad_1.0x1.0mm
U7: LM25088MH-2; SOP65P640X120-17N; Manufacturer_Part_Number LM25088MH-2

Connections:
+BATT: C18.1, C19.1, C20.1, C21.1, C23.1, C28.2, Q4.3 (D), U7.1 (VIN); also elsewhere on the board
/5V Power Supply/VOUT: C34.1, C35.1, C36.1, CP4.1, D7.2 (A), L1.2, R31.1, U7.9 (OUT); also elsewhere on the board
/5V Power Supply/Vcc: C29.1, D7.1 (K), R24.2, U7.16 (VCC)
GND: C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C27.2, C28.1, C29.2, C34.2, C35.2, C36.2, CP4.2, R27.2, R28.2, R33.2, U7.6 (GND), U7.11 (CSG), U7.17 (EPAD); also elsewhere on the board
unnamed: C22.1, R24.1, U7.4 (RAMP)
unnamed: C24.1, U7.3 (SS)
unnamed: C26.1, R27.1, U7.5 (RT/SYNC)
unnamed: C26.2, TP14.1
unnamed: C27.1, U7.10 (DITH)
unnamed: C30.1, D8.3 (K), L1.1, Q4.1 (S), R30.1, U7.13 (SW)
unnamed: C30.2, U7.15 (BOOT)
unnamed: C31.1, R29.2, R32.2, R33.1, U7.8 (FB)
unnamed: C31.2, C32.2, U7.7 (COMP)
unnamed: C32.1, R29.1
unnamed: C33.1, D8.1 (A1), D8.2, R28.1, U7.12 (CS)
unnamed: C33.2, R30.2
unnamed: Q4.2 (G), U7.14 (HG)
unnamed: R31.2, R32.1

Notes on the sheet:
"kelvin-connection"

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
Board: 4 copper layers, 114.0 x 65.0 mm, 115 parts (56 on the bottom side), 82 nets.

Other parts of the board:
J2#2: Raspberry_Pi_2_3; PinHeader_2x20_P2.54mm_Vertical
mouse-bite-2mm-slot, mouse-bite-2mm-slot#2, mouse-bite-2mm-slot#3, mouse-bite-2mm-slot#4: VAL**; mouse-bite-2mm-slot

Their connections:
+3V3_PI: J2#2.1, J2#2.17; also elsewhere on the board
+5V: J2#2.2, J2#2.4; also elsewhere on the board
/BMI_INT: J2#2.22; also elsewhere on the board
/CAN_INT: J2#2.16; also elsewhere on the board
/CS_ACCEL: J2#2.26; also elsewhere on the board
/CS_CAN: J2#2.36; also elsewhere on the board
/CS_GYRO: J2#2.24; also elsewhere on the board
/ID_SC: J2#2.28; also elsewhere on the board
/ID_SD: J2#2.27; also elsewhere on the board
/LED0: J2#2.32; also elsewhere on the board
/LED1: J2#2.33; also elsewhere on the board
/MISO_CAN: J2#2.35; also elsewhere on the board
/MISO_IMU: J2#2.21; also elsewhere on the board
/MOSI_CAN: J2#2.38; also elsewhere on the board
/MOSI_IMU: J2#2.19; also elsewhere on the board
/SCL: J2#2.5; also elsewhere on the board
/SCLK_CAN: J2#2.40; also elsewhere on the board
/SCLK_IMU: J2#2.23; also elsewhere on the board
/SDA: J2#2.3; also elsewhere on the board
GND: J2#2.6, J2#2.9, J2#2.14, J2#2.20, J2#2.25, J2#2.30, J2#2.34, J2#2.39; also elsewhere on the board
unnamed 59: J2#2.7; also elsewhere on the board
unnamed 60: J2#2.8; also elsewhere on the board
unnamed 61: J2#2.10; also elsewhere on the board
unnamed 62: J2#2.11; also elsewhere on the board
unnamed 63: J2#2.12; also elsewhere on the board
unnamed 64: J2#2.13; also elsewhere on the board
unnamed 65: J2#2.15; also elsewhere on the board
unnamed 66: J2#2.18; also elsewhere on the board
unnamed 67: J2#2.29; also elsewhere on the board
unnamed 68: J2#2.31; also elsewhere on the board
unnamed 69: J2#2.37; also elsewhere on the board

## Commit log

2021-11-26 [main] update zvd resistor values
2021-11-26 update todo
2021-11-26 update pdf
2021-11-26 remove cap from mcp2551
2021-11-27 update reference ids, assign value to c8
2021-11-27 add fp-lib-table
2021-11-28 no longer a hat lol
2021-12-02 [schematic] fix 3v3 symbol pin to use 3v3_pi instead of 5V_SRV
2021-12-04 [power supply] basic schematic for new 5V power supply, LM25088MH-2
2021-12-07 power supply overhaul
2021-12-18 final final sch
2021-12-19 [pcb] added copper planes
2021-12-21 ready?
2021-12-21 add mousebites
2021-12-21 added vias and graphics
2021-12-21 ordered
2022-01-11 [rev.2 fixes] - fix Q4 net pin assignment - removed UVLO - fix kelvin connection on R_sense - fix MCP2515 symbol + pinout - changed oscillator capacitors for 18uF load capacitance - PCA9615 biasing r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
